Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: d44965e4-297b-4d73-b8b6-f9699f11791d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: Huup_Module_B1.ifc
Time: 2026-01-30T23:11:34+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcFurnishingElement: Huup modules B1&B2:Huup_Module_B1, Huup modules B1&B2:Huup_Module_B1:354607
In: Level 1
Type - Material: Upholstry, <Unnamed>, Oak
Type - Pset_FurnitureTypeCommon - Description: Upholstered bench with solid wood frame.
Type - Pset_ManufacturerTypeInformation - Manufacturer: Arktis
Pset_QuantityTakeOff - Reference: Huup_Module_B1
