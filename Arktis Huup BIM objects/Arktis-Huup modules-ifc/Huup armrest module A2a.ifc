Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 617969a3-9017-4cb6-9a9d-f8991f765fa3, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: Huup armrest module A2a.ifc
Time: 2026-07-26T12:53:41+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.90.15 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcFurnishingElement: Huup armrest module A:A2a, Huup armrest module A:A2a:353076
In: Level 1
Type - Material: Default Upholstry, Oak
Type - Pset_FurnitureTypeCommon - Description: Upholstered bench with armrest in solid wood frame.
Type - Pset_ManufacturerTypeInformation - Manufacturer: Arktis
Pset_QuantityTakeOff - Reference: A2a
